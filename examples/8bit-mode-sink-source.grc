options:
  parameters:
    author: RT
    generate_options: qt_gui
    id: hello_gr_bladerf
    output_language: python
    title: hello gr-bladerf
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    rangeType: int
    start: '0'
    step: '1'
    stop: '254'
    value: '1'
  states: {}
- name: bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: freq_sig
  id: variable_qtgui_range
  parameters:
    label: CW Frequency
    rangeType: int
    start: '0'
    step: int(100e3)
    stop: int(samp_rate/2)
    value: int(2.5e6)
  states: {}
- name: ref_clk
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain Sink
    rangeType: int
    start: '-20'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: freq_sig
    offset: '0'
    phase: '0.1'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: bw
    dac: '10000'
    dc_calibration: LPF_TUNING
    device_id: 52f4b4c4e1164ce3a7b89d3e47c8c0e8
    fpga_image: /home/rthomp/code/fpga-images/hostedxA9-v0.15.0-8bit-mode/hostedxA9.rbf
    fpga_reload: 'False'
    freq: freq
    gain0: rf_gain
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: ref_clk
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: bw
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: 96707f3c6ffcba3fcea7f8ae85c04178
    fpga_image: /home/rthomp/code/fpga-images/hostedx115-latest.rbf
    fpga_reload: 'False'
    freq: freq
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: ref_clk
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 10e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', bladeRF_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [bladeRF_source_0, '0', qtgui_const_sink_x_0, '0']
- [bladeRF_source_0, '0', qtgui_freq_sink_x_1, '0']
- [bladeRF_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
