options:
  parameters:
    author: Greg Warnes <greg@warnes-wireless.com>
    copyright: '2022'
    generate_options: qt_gui
    id: test_txrx
    output_language: python
    title: Test Tx and Rx using a simple cosine wave
  states: {}

blocks:
- name: bandwidth
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: '[1,3,1,1]'
    lbl: Bandwidth
    maxFreqHz: 56e6
    minFreqHz: 0.2e6
    outputmsgname: bandwidth
    value: 2e6
  states: {}
- name: cos_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: '[4, 2, 1, 1]'
    label: Cos Amplitude
    start: '0'
    step: '0.1'
    stop: '2'
    value: 1/sqrt(2)
  states: {}
- name: cos_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3, 2, 1, 1]'
    label: Cos Frequency (Hz)
    start: '1'
    step: 1e2
    stop: 10e3
    value: 1e3
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: '[1, 2, 1, 1]'
    lbl: Frequency
    maxFreqHz: 6000e6
    minFreqHz: 70e6
    value: 700e6
  states: {}
- name: rx_gain_rf
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: RX Gain - RF (db)
    start: '-16'
    step: '1'
    stop: '60'
    value: '1'
  states: {}
- name: samp_rate
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: '[1,1,1,1]'
    lbl: Sample Rate
    maxFreqHz: 61.44e6
    minFreqHz: 0.521e6
    outputmsgname: samp_rate
    value: 4e6
  states: {}
- name: tx_clip_limit
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,1
    label: TX Clipping Limit
    start: '0.001'
    step: '0.001'
    stop: '2.000'
    value: '1'
  states: {}
- name: tx_gain_rf
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 1
    label: TX Gain - RF (db)
    start: '-24'
    step: '1'
    stop: '66'
    value: '22'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,1
    label: Volume
    start: '0.1'
    step: '0.1'
    stop: '20'
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: 1/sqrt(2)
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: cos_amp
    freq: cos_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dcoff: '[0, 0]'
    device_id: '0'
    fpga_image: ''
    fpga_reload: 'True'
    freq: freq
    gain0: tx_gain_rf
    gain1: '10'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance: '[0, 0]'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: '0'
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    show_v1: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_iq_balance: 'False'
    use_iq_dcoff: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw: bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '2'
    dc_offset_mode1: '0'
    dcoff: '[0, 0]'
    device_id: '0'
    fpga_image: ''
    fpga_reload: 'False'
    freq: freq
    gain0: rx_gain_rf
    gain1: '10'
    gain_mode0: 'True'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance: '[0, 0]'
    iq_balance_mode0: '2'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: '0'
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'True'
    show_v1: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_iq_balance: 'False'
    use_iq_dcoff: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: blocks_correctiq_man_0
  id: blocks_correctiq_man
  parameters:
    imag: '0.0'
    real: '0.0'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: iqlevels_iqlevels_0
  id: iqlevels_iqlevels
  parameters:
    nsamples: '100'
    sample_rate: samp_rate
    showlevels: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: TX
    label2: RX
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: RX
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: green
    color3: red
    color4: magenta
    ctrlpanel: 'True'
    grid: 'True'
    label1: TX - I
    label2: TX - Q
    label3: RX - I
    label4: RX - Q
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    ctrlpanel: 'True'
    label1: RX - I
    label2: RX - Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rail_cc_0
  id: rail_cc
  parameters:
    high_clipping: tx_clip_limit
    low_clipping: '-tx_clip_limit'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0, '0', rail_cc_0, '0']
- [bladeRF_source_0, '0', analog_agc_xx_0, '0']
- [bladeRF_source_0, '0', iqlevels_iqlevels_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [rail_cc_0, '0', bladeRF_sink_0, '0']
- [rail_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [rail_cc_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
