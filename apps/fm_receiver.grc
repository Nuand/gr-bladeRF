options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 100e3
    stop: 110e6
    value: 102.9e6
  states: {}
- name: power
  id: variable_qtgui_label
  parameters:
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '20000'
    chan_rate: samp_rate/10
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bb_gain0: '20'
    bb_gain1: '20'
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw0: '500000'
    bw1: '200000'
    corr0: '0'
    corr1: '0'
    dac: '8000'
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    fpga_image: test123
    fpga_reload: 'True'
    freq0: freq
    freq1: 1e8
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    nchan: '1'
    out_clk: 'False'
    power_monitoring: Enable
    ref_clk: '0'
    sample_rate: samp_rate
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    type: fc32
    verbosity: warning
    xb200: none
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("POWER")
    period: '1000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: power
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [bladeRF_source_0, '0', rational_resampler_xxx_0, '0']
- [bladeRF_source_0, pmic_out, blocks_msgpair_to_var_0, inpair]
- [blocks_message_strobe_0, strobe, bladeRF_source_0, pmic_in]
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
