options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 102.2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    args: '""'
    bb_gain0: '20'
    bb_gain1: '20'
    bias_tee0: 'False'
    bias_tee1: 'False'
    bw0: '200000'
    bw1: '200000'
    corr0: '0'
    corr1: '0'
    dac: '10000'
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    fpga_image: ''
    freq0: freq
    freq1: 1e8
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    nchan: '1'
    out_clk: 'False'
    power_monitoring: 'False'
    ref_clk: ''
    sample_rate: samp_rate
    type: fc32
    xb_2000: 222M
    xb_2001: auto
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [bladeRF_source_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
