options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 100e3
    stop: 110e6
    value: 102.9e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: power
  id: variable_qtgui_label
  parameters:
    type: real
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '20000'
    chan_rate: samp_rate/10
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    bw: '2000000'
    dac: '6000'
    dc_calibration: RX_LPF
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    dcoff: '[0, 0]'
    device_id: '0'
    fpga_image: test123
    fpga_reload: 'False'
    freq: freq
    gain0: rf_gain
    gain1: '10'
    gain_mode0: 'True'
    gain_mode1: 'False'
    if_gain0: if_gain
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance: '[0, 0]'
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: bypassed
    metadata: 'True'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: samp_rate
    sampling: external
    show_pmic: 'False'
    show_v1: 'False'
    smb: 10e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J71_4
    trigger_signal1: J51_1
    use_dac: 'True'
    use_iq_balance: 'False'
    use_iq_dcoff: 'False'
    verbosity: info
    xb200: none
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("POWER")
    period: '1000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: power
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [bladeRF_source_0, '0', qtgui_freq_sink_x_0, '0']
- [bladeRF_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_message_strobe_0, strobe, blocks_msgpair_to_var_0, inpair]
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
